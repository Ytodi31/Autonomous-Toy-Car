Commit message: feat : Change LiDAR mount height and LiDAR properties

File: toycar/urdf/toycar.urdf (robot description, URDF)
Before this commit: robot toycar, 9 links, 8 joints
Joints:
- joint imu_joint: origin xyz=0.03 0.6 0.15 rpy=0 0 0 -> xyz=0.03 0.6 0.25 rpy=0 0 0
